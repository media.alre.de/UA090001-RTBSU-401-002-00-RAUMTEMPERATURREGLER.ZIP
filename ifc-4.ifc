Properties of the parts of a building model (IFC4)

# File
Description: Raumtemperaturregler UP, 230 VAC, Öffner, Nachtabsenkung, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UA090001, Raumtemperaturregler UP, 230 VAC, Öffner, Nachtabsenkung
In: Raum
Description: Elektromechanischer Unterputz-Raumtemperaturregler zur Regelung oder Überwachung von Temperaturen in Büros, Wohnräumen und Hotels. In Verbindung mit dem entsprechenden Deckelset passend in alle gängigen Schalterprogramme. Passende Deckelset-Nr. JZ-001.xxx. Geeignet für alle Heizungsarten. Durch die thermische Rückführung wird eine sehr genaue Schaltdifferenz erreicht. Mit der unter dem Einstellknopf befindlichen Bereichseinengung kann der Einstellbereich verändert werden. Bei Beschalten der Klemme ECO mit 230 VAC (z. B. mit Uhrenregler oder Schaltzeituhr) wird auf eine um ca. 4 K geringere Temperatur geregelt. VDE geprüft. Einfacher elektrischer Anschluss ohne Schrauben. Neue Klemmen für eine einfache und schnelle Installation. Vereinfachte Verdrahtung durch Farbcodierung der Klemmen. Zeitersparnis durch Baukastenprinzip: Praktische Reihenfolge der Montage von Regler, Rahmen und Abdeckung. Geringes Einbauvolumen für eine komfortable und schnelle Montage in der Unterputzdose. Temperaturregelung bereits ohne Abdeckung möglich. Geschlossene Bauform. Optimale Schraubenaufnahme. Die Farbe des Unterteils ist anthrazit und die Farbe des Oberteils entspricht dem gewählten Deckelset.; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UA090001; ModelLabel: RTBSU-401.002#00; GlobalTradeItemNumber: 4050528074195; ProductURL: https://alre.de/produkt_UA090001
Pset_Specification - NominalLength: 0.071 m; NominalWidth: 0.071 m; NominalDepth: 0.0418 m; NetWeight: 0.049
Pset_ALRE_ETIM_Properties - Montageart: Unterputz; Farbe: anthrazit; Breite: 71; Höhe: 71; Tiefe: 41.8; Anschluss: drei-/vieradrig; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Öffner (NC); Messbereich: 5; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Bimetall; Klasse des Temperaturreglers: I; Schutzart (NEMA): sonstige; Verdeckte Bedienung: no; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 0; Temperatur ablesbar: no; Max. Kontaktbelastung: 10; Differenzwert: 0.5; Sensor extern: no; Thermische Rückkopplung: parallel; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: no; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UA090001.pdf
